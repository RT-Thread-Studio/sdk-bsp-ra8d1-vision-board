# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: packages\LVGL-9.0.0\src\tick;packages\LVGL-9.0.0\src\others\gridnav;packages\LVGL-9.0.0\src\widgets\button;packages\LVGL-9.0.0\src\draw;rt-thread\components\drivers\include;packages\LVGL-9.0.0\src\drivers\display\st7796;packages\LVGL-9.0.0\src\draw\sw\blend;packages\LVGL-9.0.0\src\stdlib;packages\LVGL-9.0.0\src\widgets\image;packages\LVGL-9.0.0\src\widgets\msgbox;packages\LVGL-9.0.0\src\widgets\canvas;packages\LVGL-9.0.0\src\drivers\x11;packages\LVGL-9.0.0\src\drivers;packages\LVGL-9.0.0\src\draw\sw\arm2d;packages\LVGL-9.0.0\src\widgets\buttonmatrix;packages\gt9147-v1.1.0\inc;packages\LVGL-9.0.0\src\themes\default;packages\LVGL-9.0.0\src\widgets\win;packages\LVGL-9.0.0\src\drivers\evdev;packages\LVGL-9.0.0\src\font;rt-thread\components\drivers\include;packages\LVGL-9.0.0\src\drivers\display\st7789;packages\LVGL-9.0.0\src\draw\nxp\pxp;packages\CmBacktrace-v1.4.1;rt-thread\components\libc\posix\io\epoll;packages\LVGL-9.0.0\src\others\fragment;board\lvgl;packages\LVGL-9.0.0\src\indev;packages\LVGL-9.0.0\src\widgets\chart;packages\LVGL-9.0.0\src\libs\libpng;packages\LVGL-9.0.0\src\widgets\led;board\lvgl\demo;board;packages\LVGL-9.0.0\src\drivers\display\ili9341;packages\LVGL-9.0.0\src;packages\LVGL-9.0.0\src\widgets\keyboard;packages\LVGL-9.0.0\src\libs\ffmpeg;packages\LVGL-9.0.0\src\draw\renesas\dave2d;packages\LVGL-9.0.0\src\widgets\dropdown;packages\LVGL-9.0.0\src\draw\sw;packages\LVGL-9.0.0\src\libs\lodepng;packages\LVGL-9.0.0\src\layouts;packages\LVGL-9.0.0\src\libs\freetype;rt-thread\components\drivers\include;packages\LVGL-9.0.0\src\widgets\line;packages\LVGL-9.0.0\src\widgets\bar;packages\LVGL-9.0.0\src\widgets\objx_templ;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;packages\LVGL-9.0.0\src\draw\sdl;packages\LVGL-9.0.0\src\widgets\switch;packages\LVGL-9.0.0\src\layouts\flex;board\ports;packages\LVGL-9.0.0\src\others\sysmon;packages\LVGL-9.0.0\src\drivers\display\drm;packages\LVGL-9.0.0\src\drivers\display\lcd;packages\LVGL-9.0.0\src\libs\gif;packages\LVGL-9.0.0\src\layouts\grid;packages\LVGL-9.0.0\src\libs\rle;packages\LVGL-9.0.0\src\others\observer;packages\LVGL-9.0.0\src\libs\libjpeg_turbo;packages\LVGL-9.0.0\src\widgets\menu;packages\LVGL-9.0.0\src\drivers\sdl;rt-thread\components\libc\posix\io\poll;packages\LVGL-9.0.0\src\widgets\animimage;rt-thread\components\libc\compilers\common\extension;packages\LVGL-9.0.0\src\widgets\scale;packages\LVGL-9.0.0\src\stdlib\builtin;packages\LVGL-9.0.0\src\others\file_explorer;packages\LVGL-9.0.0\src\others\imgfont;packages\LVGL-9.0.0\src\draw\nxp\vglite;packages\LVGL-9.0.0\src\draw\vg_lite;packages\LVGL-9.0.0\src\widgets\textarea;packages\LVGL-9.0.0\src\misc\cache;packages\LVGL-9.0.0\src\widgets\list;packages\i2c-tools-v1.0.0\src;rt-thread\components\drivers\include;board\lvgl\arm-2d;packages\LVGL-9.0.0\src\core;packages\LVGL-9.0.0\src\libs\rlottie;packages\LVGL-9.0.0\src\libs\bin_decoder;rt-thread\libcpu\arm\cortex-m85;packages\LVGL-9.0.0\src\libs\barcode;packages\LVGL-9.0.0\env_support\rt-thread;board\lvgl\arm-2d\Include\template;packages\LVGL-9.0.0\src\widgets\spinner;packages\LVGL-9.0.0\src\others\snapshot;packages\LVGL-9.0.0\src\libs\fsdrv;packages\LVGL-9.0.0\src\libs\qrcode;packages\LVGL-9.0.0\src\widgets\tabview;packages\LVGL-9.0.0\src\libs\thorvg;rt-thread\components\drivers\include;packages\LVGL-9.0.0\src\themes;packages\i2c-tools-v1.0.0;rt-thread\components\finsh;packages\LVGL-9.0.0\src\draw\sw\blend\neon;packages\LVGL-9.0.0\src\others\ime;packages\LVGL-9.0.0\src\others\vg_lite_tvg;rt-thread\components\libc\compilers\common\extension\fcntl\octal;board\lvgl\arm-2d\Include;rt-thread\components\libc\posix\ipc;packages\LVGL-9.0.0\src\widgets\imagebutton;packages\LVGL-9.0.0\src\libs\tiny_ttf;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\io\eventfd;packages\LVGL-9.0.0\src\misc;packages\LVGL-9.0.0\src\drivers\windows;packages\LVGL-9.0.0\src\drivers\nuttx;rt-thread\components\libc\cplusplus;packages\LVGL-9.0.0\src\drivers\display\tft_espi;packages\LVGL-9.0.0\src\drivers\display\st7735;packages\LVGL-9.0.0\src\widgets\tileview;packages\LVGL-9.0.0\src\themes\mono;packages\LVGL-9.0.0\src\widgets\roller;packages\LVGL-9.0.0\src\display;packages\LVGL-9.0.0\src\widgets\calendar;packages\LVGL-9.0.0\src\widgets\slider;packages\LVGL-9.0.0\src\others\monkey;packages\LVGL-9.0.0\src\libs\lz4;packages\LVGL-9.0.0\src\widgets\spinbox;.;packages\LVGL-9.0.0\src\widgets\label;packages\LVGL-9.0.0\src\libs\tjpgd;packages\LVGL-9.0.0\src\draw\sw\blend\arm2d;packages\LVGL-9.0.0\src\libs\bmp;packages\LVGL-9.0.0\src\widgets\arc;libraries\HAL_Drivers\config;packages\LVGL-9.0.0\src\drivers\display\fb;rt-thread\include;packages\LVGL-9.0.0\src\widgets\span;packages\LVGL-9.0.0\src\widgets\checkbox;libraries\HAL_Drivers;rt-thread\libcpu\arm\common;packages\LVGL-9.0.0\src\osal;packages\LVGL-9.0.0\src\widgets\table;packages\LVGL-9.0.0\src\themes\simple
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_flash_log.c cmb_port.c cm_backtrace.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group gt9147
    packages/gt9147-v1.1.0/src/: gt9147.c
  group i2c-tools
    packages/i2c-tools-v1.0.0/src/: i2c_utils.cpp i2c_tools.cpp
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group LVGL
    packages/LVGL-9.0.0/src/draw/renesas/dave2d/: lv_draw_dave2d_label.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_image.c lv_draw_dave2d_utils.c lv_draw_dave2d.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_line.c lv_draw_dave2d_triangle.c lv_draw_dave2d_arc.c
    packages/LVGL-9.0.0/src/others/sysmon/: lv_sysmon.c
    packages/LVGL-9.0.0/src/libs/freetype/: lv_freetype_image.c lv_freetype_glyph.c lv_freetype_outline.c lv_freetype.c lv_ftsystem.c
    packages/LVGL-9.0.0/src/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-9.0.0/src/stdlib/clib/: lv_string_clib.c lv_sprintf_clib.c lv_mem_core_clib.c
    packages/LVGL-9.0.0/src/widgets/spinner/: lv_spinner.c
    packages/LVGL-9.0.0/src/widgets/arc/: lv_arc.c
    packages/LVGL-9.0.0/src/indev/: lv_indev_scroll.c lv_indev.c
    packages/LVGL-9.0.0/src/stdlib/builtin/: lv_string_builtin.c lv_tlsf.c lv_sprintf_builtin.c lv_mem_core_builtin.c
    packages/LVGL-9.0.0/src/misc/: lv_async.c lv_anim.c lv_profiler_builtin.c lv_rb.c lv_style_gen.c lv_ll.c lv_style.c lv_anim_timeline.c lv_log.c lv_area.c lv_lru.c lv_array.c lv_math.c lv_text.c lv_bidi.c lv_templ.c lv_color_op.c lv_event.c lv_color.c lv_timer.c lv_utils.c lv_fs.c lv_palette.c lv_text_ap.c
    packages/LVGL-9.0.0/src/osal/: lv_pthread.c lv_cmsis_rtos2.c lv_os_none.c lv_rtthread.c lv_windows.c lv_freertos.c
    packages/LVGL-9.0.0/src/widgets/button/: lv_button.c
    packages/LVGL-9.0.0/src/draw/nxp/vglite/: lv_vglite_matrix.c lv_draw_vglite_triangle.c lv_draw_vglite_arc.c lv_vglite_utils.c lv_draw_vglite_img.c lv_draw_vglite_fill.c lv_draw_buf_vglite.c lv_draw_vglite_line.c lv_draw_vglite_border.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_vglite_path.c lv_vglite_buf.c lv_draw_vglite.c
    packages/LVGL-9.0.0/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    packages/LVGL-9.0.0/src/core/: lv_obj_class.c lv_obj_draw.c lv_obj_scroll.c lv_obj_style.c lv_obj_tree.c lv_group.c lv_obj_pos.c lv_obj.c lv_obj_event.c lv_obj_style_gen.c lv_obj_property.c lv_obj_id_builtin.c lv_refr.c
    packages/LVGL-9.0.0/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    packages/LVGL-9.0.0/src/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-9.0.0/src/draw/vg_lite/: lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_line.c lv_draw_vg_lite_arc.c lv_vg_lite_math.c lv_draw_buf_vg_lite.c lv_vg_lite_utils.c lv_vg_lite_decoder.c lv_draw_vg_lite_img.c lv_vg_lite_path.c lv_draw_vg_lite.c lv_draw_vg_lite_border.c lv_draw_vg_lite_label.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_vector.c lv_draw_vg_lite_mask_rect.c
    packages/LVGL-9.0.0/src/widgets/roller/: lv_roller.c
    packages/LVGL-9.0.0/src/widgets/bar/: lv_bar.c
    packages/LVGL-9.0.0/src/drivers/nuttx/: lv_nuttx_libuv.c lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_lcd.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    packages/LVGL-9.0.0/src/drivers/display/st7796/: lv_st7796.c
    packages/LVGL-9.0.0/src/libs/fsdrv/: lv_fs_memfs.c lv_fs_win32.c lv_fs_posix.c lv_fs_fatfs.c lv_fs_cbfs.c lv_fs_stdio.c
    packages/LVGL-9.0.0/src/font/: lv_font_montserrat_16.c lv_font_montserrat_14.c lv_font_montserrat_12.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_34.c lv_font_montserrat_40.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_38.c lv_font_unscii_16.c lv_font_montserrat_26.c lv_font_montserrat_46.c lv_font_montserrat_36.c lv_font_montserrat_24.c lv_font_fmt_txt.c lv_font_simsun_16_cjk.c lv_binfont_loader.c lv_font_montserrat_22.c lv_font_unscii_8.c lv_font_montserrat_10.c lv_font.c lv_font_montserrat_44.c lv_font_montserrat_42.c lv_font_montserrat_18.c lv_font_montserrat_28_compressed.c lv_font_montserrat_20.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_montserrat_32.c
    packages/LVGL-9.0.0/src/themes/: lv_theme.c
    packages/LVGL-9.0.0/src/widgets/checkbox/: lv_checkbox.c
    packages/LVGL-9.0.0/src/widgets/line/: lv_line.c
    packages/LVGL-9.0.0/src/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c
    packages/LVGL-9.0.0/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    packages/LVGL-9.0.0/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    packages/LVGL-9.0.0/src/layouts/grid/: lv_grid.c
    packages/LVGL-9.0.0/src/widgets/switch/: lv_switch.c
    packages/LVGL-9.0.0/src/widgets/menu/: lv_menu.c
    packages/LVGL-9.0.0/src/libs/bmp/: lv_bmp.c
    packages/LVGL-9.0.0/src/drivers/display/fb/: lv_linux_fbdev.c
    packages/LVGL-9.0.0/src/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-9.0.0/src/widgets/tileview/: lv_tileview.c
    packages/LVGL-9.0.0/src/drivers/windows/: lv_windows_input.c lv_windows_display.c lv_windows_context.c
    packages/LVGL-9.0.0/src/draw/: lv_draw_image.c lv_draw.c lv_draw_label.c lv_draw_vector.c lv_draw_rect.c lv_image_buf.c lv_image_decoder.c lv_draw_line.c lv_draw_triangle.c lv_draw_buf.c lv_draw_mask.c lv_draw_arc.c
    packages/LVGL-9.0.0/src/widgets/table/: lv_table.c
    packages/LVGL-9.0.0/src/draw/sw/: lv_draw_sw_letter.c lv_draw_sw_vector.c lv_draw_sw_border.c lv_draw_sw_mask.c lv_draw_sw_gradient.c lv_draw_sw_mask_rect.c lv_draw_sw_box_shadow.c lv_draw_sw_line.c lv_draw_sw_arc.c lv_draw_sw.c lv_draw_sw_fill.c lv_draw_sw_triangle.c lv_draw_sw_img.c lv_draw_sw_transform.c
    packages/LVGL-9.0.0/src/others/vg_lite_tvg/: vg_lite_matrix.c
    packages/LVGL-9.0.0/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    packages/LVGL-9.0.0/src/display/: lv_display.c
    packages/LVGL-9.0.0/src/libs/rlottie/: lv_rlottie.c
    packages/LVGL-9.0.0/src/libs/lz4/: lz4.c
    packages/LVGL-9.0.0/src/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-9.0.0/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_fill.c lv_pxp_utils.c lv_pxp_osa.c lv_pxp_cfg.c lv_draw_buf_pxp.c lv_draw_pxp_img.c lv_draw_pxp_layer.c
    packages/LVGL-9.0.0/src/libs/barcode/: code128.c lv_barcode.c
    packages/LVGL-9.0.0/src/widgets/tabview/: lv_tabview.c
    packages/LVGL-9.0.0/src/others/monkey/: lv_monkey.c
    packages/LVGL-9.0.0/src/draw/sw/blend/: lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend.c
    packages/LVGL-9.0.0/src/drivers/display/ili9341/: lv_ili9341.c
    packages/LVGL-9.0.0/src/misc/cache/: lv_cache_entry.c lv_cache.c lv_image_cache.c _lv_cache_lru_rb.c
    packages/LVGL-9.0.0/src/others/observer/: lv_observer.c
    packages/LVGL-9.0.0/src/themes/simple/: lv_theme_simple.c
    packages/LVGL-9.0.0/src/others/ime/: lv_ime_pinyin.c
    packages/LVGL-9.0.0/src/widgets/textarea/: lv_textarea.c
    packages/LVGL-9.0.0/src/stdlib/: lv_mem.c
    packages/LVGL-9.0.0/src/stdlib/rtthread/: lv_sprintf_rtthread.c lv_mem_core_rtthread.c lv_string_rtthread.c
    packages/LVGL-9.0.0/src/libs/lodepng/: lodepng.c lv_lodepng.c
    packages/LVGL-9.0.0/src/widgets/chart/: lv_chart.c
    packages/LVGL-9.0.0/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-9.0.0/src/widgets/led/: lv_led.c
    packages/LVGL-9.0.0/src/widgets/image/: lv_image.c
    packages/LVGL-9.0.0/src/tick/: lv_tick.c
    packages/LVGL-9.0.0/src/drivers/evdev/: lv_evdev.c
    packages/LVGL-9.0.0/src/widgets/dropdown/: lv_dropdown.c
    packages/LVGL-9.0.0/src/: lv_init.c
    packages/LVGL-9.0.0/src/widgets/label/: lv_label.c
    packages/LVGL-9.0.0/src/drivers/display/drm/: lv_linux_drm.c
    packages/LVGL-9.0.0/src/widgets/canvas/: lv_canvas.c
    packages/LVGL-9.0.0/src/drivers/display/st7735/: lv_st7735.c
    packages/LVGL-9.0.0/src/others/file_explorer/: lv_file_explorer.c
    packages/LVGL-9.0.0/src/widgets/slider/: lv_slider.c
    packages/LVGL-9.0.0/src/stdlib/micropython/: lv_mem_core_micropython.c
    packages/LVGL-9.0.0/src/libs/bin_decoder/: lv_bin_decoder.c
    packages/LVGL-9.0.0/src/drivers/display/st7789/: lv_st7789.c
    packages/LVGL-9.0.0/src/libs/rle/: lv_rle.c
    packages/LVGL-9.0.0/src/widgets/list/: lv_list.c
    packages/LVGL-9.0.0/src/widgets/scale/: lv_scale.c
    packages/LVGL-9.0.0/src/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-9.0.0/src/others/imgfont/: lv_imgfont.c
    packages/LVGL-9.0.0/src/layouts/flex/: lv_flex.c
    packages/LVGL-9.0.0/src/others/gridnav/: lv_gridnav.c
    packages/LVGL-9.0.0/src/widgets/span/: lv_span.c
    packages/LVGL-9.0.0/src/others/snapshot/: lv_snapshot.c
    packages/LVGL-9.0.0/src/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-9.0.0/src/layouts/: lv_layout.c
    packages/LVGL-9.0.0/src/themes/default/: lv_theme_default.c
    packages/LVGL-9.0.0/src/widgets/win/: lv_win.c
    packages/LVGL-9.0.0/src/widgets/objx_templ/: lv_objx_templ.c
    packages/LVGL-9.0.0/src/widgets/imagebutton/: lv_imagebutton.c
    packages/LVGL-9.0.0/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    packages/LVGL-9.0.0/src/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-9.0.0/src/draw/sdl/: lv_draw_sdl.c
    packages/LVGL-9.0.0/src/widgets/animimage/: lv_animimage.c
    packages/LVGL-9.0.0/src/libs/libpng/: lv_libpng.c
    packages/LVGL-9.0.0/src/themes/mono/: lv_theme_mono.c
  group LVGL-arm2d
    board/lvgl/arm-2d/Source/: arm_2d_transform.c arm_2d.c arm_2d_helium.c arm_2d_async.c __arm_2d_transform_helium.c arm_2d_draw.c __arm_2d_conversion_helium.c __arm_2d_core.c arm_2d_alpha_blending.c __arm_2d_colour_filling_with_alpha.c arm_2d_conversion.c __arm_2d_tile.c
  group LVGL-demo
    board/lvgl/demo/: lv_demo.c
    board/lvgl/demo/stress/: lv_demo_stress.c
  group LVGL-port
    board/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-9.0.0/env_support/rt-thread/: lv_rt_thread_port.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, Flex Software:RA Configuration 1.0.0

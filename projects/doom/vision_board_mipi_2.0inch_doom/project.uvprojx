# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\libcpu\arm\cortex-m85;board\ports\doom\platform;rt-thread\components\libc\posix\io\epoll;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;board\ports;rt-thread\include;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;board\ports\doom;board\ports\mipi_lcd;libraries\HAL_Drivers\config;board;rt-thread\components\finsh;libraries\HAL_Drivers;.
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Doom_port
    board/ports/doom/platform/: doomgeneric_rtthread.c i_video.c
  group Doom_source
    board/ports/doom/: w_file.c p_telept.c w_file_stdc.c v_video.c p_doors.c st_stuff.c m_bbox.c button.c icon.c i_main.c p_maputl.c z_zone.c d_main.c r_plane.c i_endoom.c w_main.c doomdef.c p_mobj.c memio.c m_menu.c i_cdmus.c st_lib.c d_loop.c statdump.c f_finale.c d_iwad.c gusconf.c i_joystick.c p_sight.c m_controls.c r_bsp.c sounds.c p_setup.c m_cheat.c tables.c m_random.c p_plats.c p_tick.c d_event.c p_user.c d_net.c doomstat.c m_argv.c p_inter.c r_draw.c info.c m_misc.c p_map.c d_mode.c i_system.c dummy.c w_wad.c p_saveg.c sha1.c w_checksum.c doomgeneric.c r_sky.c i_scale.c d_items.c g_game.c p_spec.c m_fixed.c p_pspr.c i_input.c s_sound.c p_floor.c i_timer.c dstrings.c m_config.c r_data.c p_enemy.c r_main.c i_sound.c am_map.c f_wipe.c wi_stuff.c hu_lib.c r_segs.c p_lights.c r_things.c hu_stuff.c p_switch.c p_ceilng.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sdhi.c drv_usart_v2.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0

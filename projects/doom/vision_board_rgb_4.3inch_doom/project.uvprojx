# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: .;board\ports;packages\gt9147-v1.1.0\inc;libraries\HAL_Drivers\config;rt-thread\components\libc\posix\ipc;rt-thread\include;board\ports\doom;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;board\ports\doom\platform;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\libcpu\arm\common;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\libcpu\arm\cortex-m85;rt-thread\components\drivers\include;board;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\spi;libraries\HAL_Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/touch/: touch.c
  group Doom_port
    board/ports/doom/platform/: i_video.c doomgeneric_rtthread.c
  group Doom_source
    board/ports/doom/: p_tick.c d_items.c gusconf.c i_sound.c p_inter.c p_spec.c i_input.c m_fixed.c p_saveg.c p_doors.c w_checksum.c doomgeneric.c p_map.c i_endoom.c icon.c p_sight.c d_net.c memio.c d_loop.c p_telept.c i_cdmus.c r_segs.c p_enemy.c v_video.c sha1.c statdump.c p_mobj.c m_misc.c am_map.c d_iwad.c p_maputl.c w_file_stdc.c hu_lib.c p_setup.c sounds.c g_game.c m_bbox.c r_plane.c f_finale.c i_joystick.c p_floor.c r_data.c r_sky.c m_argv.c w_wad.c p_pspr.c dstrings.c i_scale.c m_menu.c s_sound.c hu_stuff.c i_timer.c st_lib.c r_bsp.c f_wipe.c button.c d_event.c m_config.c m_controls.c p_switch.c r_main.c info.c i_main.c d_main.c z_zone.c m_cheat.c p_lights.c wi_stuff.c doomdef.c w_file.c dummy.c tables.c p_plats.c doomstat.c r_draw.c m_random.c d_mode.c i_system.c st_stuff.c p_user.c w_main.c r_things.c p_ceilng.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_sdhi.c drv_usart_v2.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group gt9147
    packages/gt9147-v1.1.0/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0

# Keil uVision project template.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Acceleration:Arm-2D Demos:Atom 1.0.2, Acceleration:Arm-2D Demos:AudioMark 1.0.2, Acceleration:Arm-2D Demos:Basics 1.0.1, Acceleration:Arm-2D Demos:ConsoleWindow 1.0.1, Acceleration:Arm-2D Demos:Gas Gauge 1.0.1, Acceleration:Arm-2D Demos:Listview 1.0.1, Acceleration:Arm-2D Demos:Menu 1.0.1, Acceleration:Arm-2D Demos:Panel 1.0.2, Acceleration:Arm-2D Demos:Progress and Status 1.0.1, Acceleration:Arm-2D Extras:Controls 1.7.7, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.3.1, Acceleration:Arm-2D Helper:Display Adapter 2.4.0, Acceleration:Arm-2D Helper:PFB 1.12.1, Acceleration:Arm-2D Helper:RTOS Helper 1.1.0, Acceleration:Arm-2D:Alpha-Blending 1.7.0, Acceleration:Arm-2D:Core 1.1.6, Acceleration:Arm-2D:Filter 1.1.6, Acceleration:Arm-2D:Transform 1.1.6, CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, Utilities:perf_counter:Core 2.3.1, Utilities:perf_counter:Porting 1.1.1, Flex Software:RA Configuration 1.0.0

# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\libc\posix\io\poll;board\ports;board\ports\mipi_lcd;rt-thread\components\drivers\include;board;libraries\HAL_Drivers;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\ipc;libraries\HAL_Drivers\config;rt-thread\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;.;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\finsh;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m85;rt-thread\components\libc\posix\io\epoll;board\ports\arm2d
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group arm2d_app
    board/ports/arm2d/: arm_2d_scene_fitness.c arm_2d_scene_histogram.c arm_2d_scene_meter.c arm_2d_scene_fan.c arm_2d_scene_bubble_charging.c arm_2d_scene_watch.c arm_2d_scene_alarm_clock.c MeterPanel.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c
    board/ports/mipi_lcd/: mipi_config.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Acceleration:Arm-2D Demos:Atom 1.0.2, Acceleration:Arm-2D Demos:AudioMark 1.0.2, Acceleration:Arm-2D Demos:Basics 1.0.1, Acceleration:Arm-2D Demos:ConsoleWindow 1.0.1, Acceleration:Arm-2D Demos:Gas Gauge 1.0.1, Acceleration:Arm-2D Demos:Listview 1.0.1, Acceleration:Arm-2D Demos:Menu 1.0.1, Acceleration:Arm-2D Demos:Panel 1.0.2, Acceleration:Arm-2D Demos:Progress and Status 1.0.1, Acceleration:Arm-2D Extras:Controls 1.7.7, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.3.1, Acceleration:Arm-2D Helper:Display Adapter 2.4.0, Acceleration:Arm-2D Helper:PFB 1.12.1, Acceleration:Arm-2D Helper:RTOS Helper 1.1.0, Acceleration:Arm-2D:Alpha-Blending 1.7.0, Acceleration:Arm-2D:Core 1.1.6, Acceleration:Arm-2D:Filter 1.1.6, Acceleration:Arm-2D:Transform 1.1.6, CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, Utilities:perf_counter:Core 2.3.1, Utilities:perf_counter:Porting 1.1.1, Flex Software:RA Configuration 1.0.0

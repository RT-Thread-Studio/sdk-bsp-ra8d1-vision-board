# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.2.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, ARM_MATH_CM85, NDEBUG, RT_USING_LIBC, MICROPY_PY_DISPLAY = 1, CMSIS_NN, __CLK_TCK=RT_TICK_PER_SECOND, TF_LITE_STATIC_MEMORY, __RTTHREAD__, __FPU_PRESENT, MICROPY_PY_SENSOR = 1
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\dfs\dfs_v1\include;packages\micropython-v1.13.0\port\modules;packages\OpenMV-v4.5.0\src\omv\alloc;.;rt-thread\components\libc\posix\io\poll;board\ports\tf-micro\third_party\flatbuffers\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;board\ports\tf-micro\third_party\kissfft;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\sal\include\dfs_net;board\ports\mipi_lcd;board\ports;board\ports\tf-micro\signal\src\kiss_fft_wrappers;rt-thread\components\fal\inc;board\ports\tf-micro\libtf;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\hal;packages\OpenMV-v4.5.0\src\omv;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;packages\rw007-v2.1.0;packages\OpenMV-v4.5.0\src\omv\ports\ra8;packages\OpenMV-v4.5.0\src\omv\modules;board\ports\CMSIS-NN;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\net\sal\impl;packages\micropython-v1.13.0\ports\renesas\boards\EK-RA8D1;board\ports\scc8660;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0;board\ports\wifi;board\ports\tf-micro;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\linalg;rt-thread\components\drivers\include;packages\rw007-v2.1.0\inc;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\libc\posix\ipc;packages\OpenMV-v4.5.0\src\hal\cmsis\include;packages\CmBacktrace-v1.4.1;board\ports\tf-micro\third_party\gemmlowp;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\carray;board\ports\tf-micro\third_party\ruy;rt-thread\components\net\sal\include;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\net\sal\include\socket;packages\OpenMV-v4.5.0\src\omv\boards\RA8;packages\micropython-v1.13.0\port\modules\machine;rt-thread\components\net\lwip\port;rt-thread\libcpu\arm\common;board\ports\CMSIS-NN\include\Internal;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\fft;packages\i2c-tools-v1.0.0\src;rt-thread\components\libc\compilers\common\extension;packages\micropython-v1.13.0\py;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\ndarray;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\user;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;board\ports\CMSIS-NN\include;rt-thread\components\finsh;rt-thread\components\drivers\wlan;board;packages\OpenMV-v4.5.0\src\omv\common;board\ports\omv_fs;rt-thread\components\libc\posix\io\epoll;board\ports\tf-micro\signal\src;rt-thread\components\net\netdev\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy;libraries\HAL_Drivers;rt-thread\include;packages\TinyUSB-v0.14.0\src;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\linalg;packages\micropython-v1.13.0\ports\renesas;packages\micropython-v1.13.0\lib\utils;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\special;packages\i2c-tools-v1.0.0;libraries\HAL_Drivers\config;rt-thread\components\drivers\include;packages\micropython-v1.13.0;packages\micropython-v1.13.0\port;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code;packages\OpenMV-v4.5.0\src\lib\libtf;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\signal;rt-thread\components\drivers\include;board\ports\tf-micro\signal\micro\kernels;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\utils;packages\OpenMV-v4.5.0\src\omv\sensors;packages\OpenMV-v4.5.0\src\omv\imlib;rt-thread\components\libc\cplusplus;rt-thread\libcpu\arm\cortex-m85;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\optimize;packages\micropython-v1.13.0\lib\libm_dbl;packages\TinyUSB-v0.14.0\rt-thread
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cm_backtrace.c cmb_port.c cmb_flash_log.c
  group CMSIS_NN
    board/ports/CMSIS-NN/Source/NNSupportFunctions/: arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8_s32.c arm_nn_lstm_step_s8_s16.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nn_lstm_update_cell_state_s16.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mult_nt_t_s4.c arm_nn_vec_mat_mult_t_s4.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_lstm_update_output_s8_s16.c arm_nn_vec_mat_mul_result_acc_s8.c arm_nn_vec_mat_mult_t_s8.c arm_nntables.c arm_s8_to_s16_unordered_with_offset.c arm_nn_lstm_calculate_gate_s8_s16.c arm_q7_to_q15_with_offset.c
    board/ports/CMSIS-NN/Source/PoolingFunctions/: arm_max_pool_s16.c arm_avgpool_get_buffer_sizes_s16.c arm_avgpool_get_buffer_sizes_s8.c arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s8.c
    board/ports/CMSIS-NN/Source/ConvolutionFunctions/: arm_nn_mat_mult_s8.c arm_depthwise_conv_get_buffer_sizes_s4.c arm_convolve_1x1_s8.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_convolve_1x1_s8_fast.c arm_depthwise_conv_3x3_s8.c arm_transpose_conv_get_buffer_sizes_s8.c arm_convolve_get_buffer_sizes_s4.c arm_convolve_s8.c arm_depthwise_conv_s4_opt.c arm_convolve_wrapper_s4.c arm_convolve_get_buffer_sizes_s8.c arm_nn_depthwise_conv_s8_core.c arm_convolve_wrapper_s8.c arm_depthwise_conv_wrapper_s16.c arm_convolve_1x1_s4.c arm_transpose_conv_s8.c arm_depthwise_conv_s8_opt.c arm_convolve_1_x_n_s8.c arm_convolve_s16.c arm_depthwise_conv_s8.c arm_convolve_1x1_s4_fast.c arm_convolve_wrapper_s16.c arm_depthwise_conv_s16.c arm_depthwise_conv_s4.c arm_nn_mat_mult_kernel_s8_s16.c arm_convolve_get_buffer_sizes_s16.c arm_depthwise_conv_wrapper_s4.c arm_depthwise_conv_fast_s16.c arm_convolve_s4.c arm_depthwise_conv_wrapper_s8.c arm_convolve_fast_s16.c arm_depthwise_conv_get_buffer_sizes_s16.c arm_nn_mat_mult_kernel_s4_s16.c
    board/ports/CMSIS-NN/Source/LSTMFunctions/: arm_lstm_unidirectional_s8_s16.c
    board/ports/CMSIS-NN/Source/SoftmaxFunctions/: arm_softmax_s8.c arm_softmax_s16.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_nn_softmax_common_s8.c
    board/ports/CMSIS-NN/Source/FullyConnectedFunctions/: arm_fully_connected_get_buffer_sizes_s16.c arm_fully_connected_get_buffer_sizes_s8.c arm_fully_connected_s4.c arm_fully_connected_s16.c arm_vector_sum_s8.c arm_fully_connected_s8.c
    board/ports/CMSIS-NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_mul_s16_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s8.c arm_elementwise_add_s8.c
    board/ports/CMSIS-NN/Source/ActivationFunctions/: arm_nn_activation_s16.c arm_relu_q7.c arm_relu_q15.c arm_relu6_s8.c
    board/ports/CMSIS-NN/Source/ConcatenationFunctions/: arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c arm_concatenation_s8_w.c
    board/ports/CMSIS-NN/Source/SVDFunctions/: arm_svdf_get_buffer_sizes_s8.c arm_svdf_s8.c arm_svdf_state_s16_s8.c
    board/ports/CMSIS-NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/ports/wifi/: drv_rw007.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_flash.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_sdhi.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
  group Fal
    rt-thread/components/fal/src/: fal_partition.c fal_flash.c fal_rtt.c fal.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group i2c-tools
    packages/i2c-tools-v1.0.0/src/: i2c_utils.cpp i2c_tools.cpp
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group micropython
    packages/micropython-v1.13.0/extmod/: machine_signal.c virtpin.c moduselect.c machine_pinbase.c vfs_reader.c modussl_axtls.c moduwebsocket.c machine_pulse.c vfs_fat.c machine_spi.c vfs_fat_diskio.c vfs_posix_file.c moduheapq.c modbtree.c utime_mphal.c moduzlib.c machine_mem.c modutimeq.c vfs_fat_file.c moducryptolib.c modussl_mbedtls.c modwebrepl.c modframebuf.c modonewire.c modubinascii.c moductypes.c modujson.c modwebsocket.c uos_dupterm.c machine_i2c.c moduhashlib.c modurandom.c vfs.c modure.c vfs_posix.c
    packages/micropython-v1.13.0/port/modules/: modfile.c modnetwork.c modutime.c modnetwork_wlan.c modpyb.c modusocket.c modutils.c moduos.c moduos_file.c modrtthread.c modffi.c
    packages/micropython-v1.13.0/lib/utils/: printf.c pyexec.c stdout_helpers.c sys_stdio_mphal.c interrupt_char.c mpirq.c
    packages/micropython-v1.13.0/py/: asmx64.c emitcommon.c objproperty.c objfilter.c modcmath.c mpprint.c binary.c modthread.c profile.c emitinlinethumb.c nlr.c modmicropython.c objgetitemiter.c objcell.c modmath.c nlrthumb.c pystack.c scheduler.c objslice.c objint.c modsys.c emitinlinextensa.c objcomplex.c stackctrl.c lexer.c builtinimport.c nlrx64.c reader.c nlrmips.c asmxtensa.c objnamedtuple.c objobject.c objenumerate.c qstr.c persistentcode.c compile.c nlrx86.c objint_mpz.c smallint.c emitnarm.c modstruct.c objpolyiter.c objexcept.c builtinevex.c nlrxtensa.c ringbuf.c repl.c objstr.c emitbc.c moduerrno.c emitnative.c objlist.c nlraarch64.c objfun.c objmap.c stream.c omvdummy.c nativeglue.c objreversed.c objnone.c objset.c objmodule.c obj.c modgc.c objtuple.c vstr.c emitnthumb.c modio.c objgenerator.c objsingleton.c mpz.c emitnxtensawin.c parse.c parsenumbase.c objbool.c sequence.c emitnx64.c modbuiltins.c argcheck.c objarray.c nlrpowerpc.c frozenmod.c asmx86.c objclosure.c map.c emitglue.c objstringio.c mpstate.c emitnx86.c objfloat.c scope.c asmarm.c modcollections.c objint_longlong.c objtype.c opmethods.c unicode.c vm.c objstrunicode.c builtinhelp.c objboundmeth.c warning.c formatfloat.c emitnxtensa.c objattrtuple.c runtime_utils.c objdict.c gc.c objzip.c objdeque.c malloc.c asmbase.c nlrsetjmp.c showbc.c parsenum.c asmthumb.c runtime.c objrange.c modarray.c pairheap.c bc.c
    packages/micropython-v1.13.0/port/native/: easyflash_module.c native_module.c
    packages/micropython-v1.13.0/port/: mpy_main.c mphalport.c mpgetcharport.c gccollect.c frozen_mpy.c mpputsnport.c mpthreadport.c
    packages/micropython-v1.13.0/drivers/bus/: softqspi.c softspi.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
  group micropython/machine
    packages/micropython-v1.13.0/port/modules/machine/: machine_rtc.c machine_adc.c machine_pwm.c machine_uart.c modmachine.c machine_hw_spi.c machine_wdt.c machine_pin.c machine_lcd.c machine_timer.c machine_hw_i2c.c
  group micropython/omv-port
    packages/micropython-v1.13.0/ports/renesas/: pyb_uart.c pyb_i2c.c machine_led.c bufhelper.c led.c tinyusb_debug.c
  group openmv/alloc
    packages/OpenMV-v4.5.0/src/omv/alloc/: xalloc.c dma_alloc.c fb_alloc.c unaligned_memcpy.c umm_malloc.c
  group openmv/common
    packages/OpenMV-v4.5.0/src/omv/common/: factoryreset.c array.c vospi.c ringbuf.c mutex.c usbdbg.c sensor_utils.c trace.c
  group openmv/dsp
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_sqrt_q15.c arm_sin_q15.c arm_sin_f32.c arm_cos_q31.c arm_sin_q31.c arm_cos_q15.c arm_cos_f32.c arm_sqrt_q31.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q15.c arm_rfft_init_q31.c
  group openmv/imlib
    packages/OpenMV-v4.5.0/src/omv/imlib/: binary.c fsort.c lbp.c agast.c stats.c mathop.c collections.c qsort.c hough.c jpeg.c stereo.c pool.c kmeans.c lodepng.c jpegd.c point.c filter.c isp.c rectangle.c sincos_tab.c hog.c font.c blob.c zbar.c lab_tab.c integral.c bayer.c edge.c draw.c integral_mw.c gif.c fmath.c haar.c dmtx.c orb.c line.c mjpeg.c framebuffer.c yuv.c lsd.c selective_search.c imlib.c qrcode.c fast.c fft.c eye.c phasecorrelation.c png.c template.c bmp.c clahe.c apriltag.c ppm.c xyz_tab.c rainbow_tab.c
  group openmv/modules
    packages/OpenMV-v4.5.0/src/omv/modules/: py_gif.c py_spi_display.c py_omv.c py_sensor.c py_image.c py_clock.c py_display.c py_mjpeg.c py_imageio.c py_helper.c py_tf.c
  group openmv/port/ra8
    packages/OpenMV-v4.5.0/src/omv/ports/ra8/: sensor.c omv_lcd.c cambus.c omv_gpio.c
  group openmv/rtt-port
    board/ports/omv_fs/: ff_wrapper.c
  group openmv/sensor
    packages/OpenMV-v4.5.0/src/omv/sensors/: frogeye2020.c ov2640.c hm0360.c ov7725.c paj6100.c ov9650.c gc2145.c hm01b0.c mt9m114.c scc8660.c gc0328.c mt9v0xx.c ov5640.c lepton.c ov7670.c ov7690.c
  group openmv/ulab
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/: transform.c compare.c numpy.c vector.c create.c filter.c poly.c approx.c stats.c numerical.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/: ndarray.c ulab.c ndarray_properties.c ulab_tools.c ndarray_operators.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/carray/: carray.c carray_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/linalg/: linalg.c linalg_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/user/: user.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/utils/: utils.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/fft/: fft_tools.c fft.c
  group openmv/ulab/scipy
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/signal/: signal.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/linalg/: linalg.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/special/: special.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/optimize/: optimize.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/: scipy.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group tensorflow
    board/ports/tf-micro/tensorflow/lite/micro/arena_allocator/: persistent_arena_buffer_allocator.cpp single_arena_buffer_allocator.cpp non_persistent_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/internal/: common.cpp quantization_util.cpp portable_tensor_utils.cpp tensor_ctypes.cpp tensor_utils.cpp
    board/ports/tf-micro/tensorflow/lite/core/api/: error_reporter.cpp tensor_utils.cpp flatbuffer_conversions.cpp
    board/ports/tf-micro/tensorflow/lite/schema/: schema_utils.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/internal/reference/: comparisons.cpp portable_tensor_utils.cpp
    board/ports/tf-micro/tensorflow/lite/micro/memory_planner/: linear_memory_planner.cpp greedy_memory_planner.cpp
    board/ports/tf-micro/tensorflow/lite/core/c/: common.cpp
    board/ports/tf-micro/tensorflow/lite/kernels/: kernel_util.cpp
  group tensorflow/cmsis_nn
    board/ports/tf-micro/tensorflow/lite/micro/kernels/cmsis_nn/: mul.cpp conv.cpp add.cpp pooling.cpp softmax.cpp svdf.cpp fully_connected.cpp depthwise_conv.cpp
  group tensorflow/kernels
    board/ports/tf-micro/tensorflow/lite/micro/kernels/: softmax_common.cpp slice.cpp circular_buffer.cpp mul_common.cpp space_to_batch_nd.cpp round.cpp maximum_minimum.cpp squared_difference.cpp broadcast_args.cpp strided_slice_common.cpp zeros_like.cpp tanh.cpp prelu.cpp shape.cpp call_once.cpp reduce_common.cpp concatenation.cpp l2norm.cpp gather_nd.cpp transpose_conv.cpp space_to_depth.cpp quantize_common.cpp micro_tensor_utils.cpp dequantize_common.cpp reduce.cpp squeeze.cpp conv_common.cpp dequantize.cpp while.cpp unpack.cpp batch_matmul.cpp lstm_eval.cpp div.cpp pooling_common.cpp cumsum.cpp strided_slice.cpp l2_pool_2d.cpp elementwise.cpp assign_variable.cpp batch_to_space_nd.cpp lstm_eval_common.cpp transpose.cpp leaky_relu_common.cpp depthwise_conv_common.cpp reshape.cpp logical.cpp unidirectional_sequence_lstm.cpp detection_postprocess.cpp sub.cpp sub_common.cpp logical_common.cpp split.cpp neg.cpp exp.cpp kernel_util.cpp leaky_relu.cpp read_variable.cpp quantize.cpp elu.cpp comparisons.cpp gather.cpp activations_common.cpp add_common.cpp if.cpp pack.cpp floor.cpp activations.cpp floor_div.cpp broadcast_to.cpp logistic.cpp hard_swish.cpp reshape_common.cpp mirror_pad.cpp floor_mod.cpp ethosu.cpp svdf_common.cpp var_handle.cpp fill.cpp resize_bilinear.cpp prelu_common.cpp add_n.cpp log_softmax.cpp pad.cpp ceil.cpp hard_swish_common.cpp resize_nearest_neighbor.cpp cast.cpp kernel_runner.cpp embedding_lookup.cpp depth_to_space.cpp split_v.cpp fully_connected_common.cpp select.cpp circular_buffer_common.cpp arg_min_max.cpp logistic_common.cpp expand_dims.cpp
    board/ports/tf-micro/tensorflow/lite/micro/cortex_m_generic/: debug_log.cpp micro_time.cpp
  group tensorflow/lib
    board/ports/tf-micro/libtf/: libtf_builtin_models.c libtf.cpp
  group tensorflow/micro
    board/ports/tf-micro/tensorflow/lite/micro/: micro_interpreter.cpp micro_resource_variable.cpp micro_allocation_info.cpp test_helper_custom_ops.cpp micro_allocator.cpp micro_interpreter_context.cpp micro_log.cpp micro_utils.cpp mock_micro_graph.cpp fake_micro_context.cpp recording_micro_allocator.cpp system_setup.cpp memory_helpers.cpp micro_interpreter_graph.cpp test_helpers.cpp micro_op_resolver.cpp micro_profiler.cpp flatbuffer_utils.cpp micro_context.cpp
    board/ports/tf-micro/tensorflow/lite/micro/tflite_bridge/: micro_error_reporter.cpp flatbuffer_conversions_bridge.cpp
  group tensorflow/signal
    board/ports/tf-micro/signal/src/: fft_auto_scale.cpp filter_bank.cpp rfft_int16.cpp msb_32.cpp filter_bank_log.cpp circular_buffer.cpp window.cpp log.cpp max_abs.cpp rfft_float.cpp energy.cpp pcan_argc_fixed.cpp filter_bank_spectral_subtraction.cpp msb_64.cpp overlap_add.cpp square_root_64.cpp filter_bank_square_root.cpp rfft_int32.cpp irfft_int32.cpp irfft_float.cpp square_root_32.cpp irfft_int16.cpp
    board/ports/tf-micro/signal/micro/kernels/: rfft.cpp energy.cpp overlap_add.cpp irfft.cpp pcan.cpp fft_auto_scale_common.cpp filter_bank_square_root.cpp filter_bank_square_root_common.cpp filter_bank.cpp framer.cpp filter_bank_spectral_subtraction.cpp delay.cpp fft_auto_scale_kernel.cpp window.cpp filter_bank_log.cpp stacker.cpp
    board/ports/tf-micro/signal/src/kiss_fft_wrappers/: kiss_fft_int16.cpp kiss_fft_int32.cpp kiss_fft_float.cpp
  group TinyUSB
    packages/TinyUSB-v0.14.0/src/class/cdc/: cdc_device.c
    packages/TinyUSB-v0.14.0/src/device/: usbd.c usbd_control.c
    packages/TinyUSB-v0.14.0/rt-thread/: usb_descriptor.c tinyusb_port.c
    packages/TinyUSB-v0.14.0/src/portable/renesas/rusb2/: dcd_rusb2.c rusb2_common.c
    packages/TinyUSB-v0.14.0/src/: tusb.c
    packages/TinyUSB-v0.14.0/rt-thread/bsp/renesas/: drv_tinyusb.c
    packages/TinyUSB-v0.14.0/src/common/: tusb_fifo.c
  group WICED
    board/ports/scc8660/: scc8660.lib
software components: Flex Software:RA Configuration 1.0.0

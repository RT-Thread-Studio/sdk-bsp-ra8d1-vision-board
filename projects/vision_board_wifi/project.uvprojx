# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\libcpu\arm\common;rt-thread\components\drivers\wlan;board;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\epoll;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\net\sal\include\socket;packages\rw007-v2.1.0\inc;rt-thread\components\libc\compilers\common\extension;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\libc\posix\ipc;rt-thread\components\net\lwip\lwip-2.0.3\src\include;libraries\HAL_Drivers\config;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board\ports\wifi;rt-thread\components\dfs\dfs_v1\include;.;rt-thread\components\drivers\spi;libraries\HAL_Drivers;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\drivers\include;packages\rw007-v2.1.0;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\libc\posix\io\eventfd;rt-thread\libcpu\arm\cortex-m85;rt-thread\components\finsh;rt-thread\components\libc\compilers\common\include;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include\dfs_net;board\ports;rt-thread\components\net\lwip\port;rt-thread\include
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/wifi/: drv_rw007.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart_v2.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group NetUtils
    packages/netutils-v1.3.3/iperf/: iperf.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0

# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: board;rt-thread\include;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m85;libraries\HAL_Drivers;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\ipc;libraries\HAL_Drivers\config;libraries\components\tinyusb\lib\rt-thread;rt-thread\components\libc\posix\io\poll;board\ports\camera;board\ports\mipi_lcd;board\ports;libraries\components\tinyusb\src;rt-thread\components\drivers\include;.;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;board\ports\camera\sensors;rt-thread\components\libc\compilers\common\include
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Camera
    board/ports/camera/: cambus.c sensor.c fmath.c sensor_utils.c
    board/ports/camera/sensors/: gc0328.c paj6100.c ov7690.c ov5640.c ov7670.c ov9650.c mt9v0xx.c hm01b0.c ov2640.c frogeye2020.c ov7725.c mt9m114.c gc2145.c hm0360.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/ports/mipi_lcd/: mipi_config.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_soft_i2c.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group TinyUSB
    board/tinyusb/: drv_tinyusb.c usb_descriptors.c
    libraries/components/tinyusb/src/class/video/: video_device.c
    libraries/components/tinyusb/src/common/: tusb_fifo.c
    libraries/components/tinyusb/src/device/: usbd.c usbd_control.c
    libraries/components/tinyusb/src/portable/renesas/rusb2/: dcd_rusb2.c rusb2_common.c
    libraries/components/tinyusb/src/: tusb.c
    libraries/components/tinyusb/lib/rt-thread/: tusb_rt_thread_port.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0

# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\drivers\include;rt-thread\include;packages\LVGL-latest\src\stdlib\builtin;packages\LVGL-latest\src\draw\renesas\dave2d;packages\LVGL-latest\src\indev;packages\LVGL-latest\src\others\snapshot;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\poll;packages\LVGL-latest\src\widgets\image;packages\LVGL-latest\src\drivers\display\drm;rt-thread\components\drivers\include;packages\LVGL-latest\src\widgets\switch;packages\LVGL-latest\src\draw\sw\blend\helium;packages\LVGL-latest\src\draw\nxp\vglite;packages\LVGL-latest\src\drivers\display\st7789;packages\LVGL-latest\src\widgets\canvas;packages\LVGL-latest\src\libs\lodepng;packages\LVGL-latest\src\layouts;rt-thread\libcpu\arm\common;packages\LVGL-latest\src\osal;packages\LVGL-latest\src\widgets\tabview;packages\LVGL-latest\src\themes\mono;packages\LVGL-latest\src\drivers\display\fb;board;packages\LVGL-latest\src\layouts\grid;packages\LVGL-latest\src\others\observer;rt-thread\components\libc\compilers\common\include;packages\LVGL-latest\src\drivers\display\st7796;packages\LVGL-latest\src\widgets\tileview;board\ports;packages\LVGL-latest\src\widgets\line;packages\LVGL-latest\src\libs\qrcode;packages\LVGL-latest\src\drivers\x11;packages\LVGL-latest\src\draw\sw;packages\LVGL-latest\src\libs\gif;packages\LVGL-latest\src\libs\libjpeg_turbo;packages\LVGL-latest\src\libs\libpng;packages\LVGL-latest\src\widgets\roller;packages\LVGL-latest\src\drivers;packages\LVGL-latest\src\draw\nxp\pxp;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\posix\ipc;packages\LVGL-latest\src\widgets\animimage;rt-thread\components\drivers\include;packages\LVGL-latest\src\libs\fsdrv;packages\LVGL-latest\src\draw\sw\arm2d;packages\LVGL-latest\src\libs\tiny_ttf;packages\LVGL-latest\src\drivers\display\st7735;packages\LVGL-latest\env_support\rt-thread;board\lvgl\demo;packages\LVGL-latest\src\widgets\scale;rt-thread\components\drivers\include;packages\LVGL-latest\src\draw\sw\blend\arm2d;packages\LVGL-latest\src\widgets\list;packages\LVGL-latest\src\drivers\evdev;packages\LVGL-latest\src\widgets\menu;rt-thread\components\drivers\touch;packages\LVGL-latest\src\drivers\display\tft_espi;libraries\HAL_Drivers;packages\LVGL-latest\src\draw\sdl;.;packages\LVGL-latest\src\widgets\table;libraries\HAL_Drivers\config;packages\LVGL-latest\src\others\file_explorer;packages\LVGL-latest\src\widgets\slider;packages\gt9147-v1.1.0\inc;packages\LVGL-latest\src\drivers\windows;packages\LVGL-latest\src\themes\simple;packages\LVGL-latest\src\widgets\label;packages\LVGL-latest\src\others\fragment;packages\LVGL-latest\src\drivers\display\lcd;board\lvgl;packages\LVGL-latest\src\libs\barcode;packages\LVGL-latest\src\libs\ffmpeg;packages\LVGL-latest\src\drivers\display\ili9341;packages\LVGL-latest\src\widgets\button;packages\LVGL-latest\src\widgets\keyboard;packages\LVGL-latest\src\font;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-latest\src\themes\default;packages\LVGL-latest\src\tick;packages\LVGL-latest\src\layouts\flex;packages\LVGL-latest\src\widgets\calendar;packages\LVGL-latest\src\widgets\arc;packages\LVGL-latest\src\draw\sw\blend\neon;packages\LVGL-latest\src\widgets\msgbox;packages\LVGL-latest\src\libs\freetype;packages\LVGL-latest\src\themes;packages\LVGL-latest\src\stdlib;packages\LVGL-latest\src\core;packages\LVGL-latest\src\draw\sw\blend;packages\LVGL-latest\src\others\monkey;packages\LVGL-latest\src\others\gridnav;packages\LVGL-latest\src\widgets\span;packages\LVGL-latest\src\widgets\checkbox;packages\LVGL-latest\src\widgets\spinner;packages\LVGL-latest\src\libs\lz4;packages\LVGL-latest\src\others\vg_lite_tvg;packages\LVGL-latest\src\widgets\win;packages\LVGL-latest\src\widgets\bar;packages\LVGL-latest\src\libs\bmp;packages\LVGL-latest\src\draw;packages\LVGL-latest\src\widgets\led;packages\LVGL-latest\src\others\sysmon;packages\LVGL-latest\src\widgets\textarea;packages\LVGL-latest\src\misc;packages\LVGL-latest\src;packages\LVGL-latest\src\others\imgfont;packages\LVGL-latest\src\drivers\sdl;rt-thread\components\drivers\include;packages\LVGL-latest\src\libs\rle;rt-thread\components\libc\posix\io\eventfd;packages\LVGL-latest\src\draw\vg_lite;rt-thread\components\finsh;packages\LVGL-latest\src\drivers\libinput;packages\LVGL-latest\src\widgets\spinbox;rt-thread\components\drivers\include;packages\LVGL-latest\src\libs\tjpgd;packages\LVGL-latest\src\libs\rlottie;packages\LVGL-latest\src\misc\cache;packages\LVGL-latest\src\libs\thorvg;packages\LVGL-latest\src\others\ime;packages\LVGL-latest\src\libs\bin_decoder;packages\LVGL-latest\src\widgets\imagebutton;packages\LVGL-latest\src\widgets\dropdown;packages\LVGL-latest\src\display;rt-thread\libcpu\arm\cortex-m85;packages\LVGL-latest\src\drivers\nuttx;packages\LVGL-latest\src\widgets\buttonmatrix;packages\LVGL-latest\src\widgets\objx_templ;packages\LVGL-latest\src\widgets\chart
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/ports/: drv_sdram.c mnt.c
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group gt9147
    packages/gt9147-v1.1.0/src/: gt9147.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group LVGL
    packages/LVGL-latest/src/draw/vg_lite/: lv_draw_vg_lite_img.c lv_draw_vg_lite_layer.c lv_vg_lite_grad.c lv_draw_vg_lite_line.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_mask_rect.c lv_vg_lite_pending.c lv_vg_lite_math.c lv_draw_buf_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_triangle.c lv_vg_lite_decoder.c lv_vg_lite_utils.c lv_draw_vg_lite_vector.c lv_draw_vg_lite_label.c lv_vg_lite_path.c
    packages/LVGL-latest/src/draw/: lv_draw_buf.c lv_draw_triangle.c lv_draw_image.c lv_draw_line.c lv_draw.c lv_image_decoder.c lv_draw_rect.c lv_draw_mask.c lv_draw_vector.c lv_draw_arc.c lv_draw_label.c
    packages/LVGL-latest/src/misc/: lv_anim_timeline.c lv_color_op.c lv_text.c lv_templ.c lv_anim.c lv_fs.c lv_ll.c lv_area.c lv_array.c lv_math.c lv_timer.c lv_event.c lv_style_gen.c lv_style.c lv_text_ap.c lv_rb.c lv_bidi.c lv_profiler_builtin.c lv_utils.c lv_log.c lv_color.c lv_lru.c lv_async.c lv_palette.c
    packages/LVGL-latest/src/core/: lv_obj_id_builtin.c lv_obj_draw.c lv_refr.c lv_obj_tree.c lv_group.c lv_obj_event.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj.c lv_obj_class.c lv_obj_style_gen.c lv_obj_property.c
    packages/LVGL-latest/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_line.c lv_draw_sw_box_shadow.c lv_draw_sw_mask_rect.c lv_draw_sw_border.c lv_draw_sw_triangle.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_transform.c lv_draw_sw.c lv_draw_sw_fill.c lv_draw_sw_mask.c lv_draw_sw_letter.c lv_draw_sw_vector.c
    packages/LVGL-latest/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    packages/LVGL-latest/src/draw/sw/blend/: lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.c
    packages/LVGL-latest/src/widgets/roller/: lv_roller.c
    packages/LVGL-latest/src/drivers/display/drm/: lv_linux_drm.c
    packages/LVGL-latest/src/draw/nxp/pxp/: lv_draw_pxp_img.c lv_draw_pxp_fill.c lv_draw_pxp_layer.c lv_draw_pxp.c lv_pxp_utils.c lv_draw_buf_pxp.c lv_pxp_cfg.c lv_pxp_osa.c
    packages/LVGL-latest/src/libs/freetype/: lv_ftsystem.c lv_freetype_outline.c lv_freetype.c lv_freetype_image.c lv_freetype_glyph.c
    packages/LVGL-latest/src/themes/: lv_theme.c
    packages/LVGL-latest/src/display/: lv_display.c
    packages/LVGL-latest/src/widgets/led/: lv_led.c
    packages/LVGL-latest/src/font/: lv_font_fmt_txt.c lv_font_montserrat_22.c lv_font_montserrat_12.c lv_font_montserrat_28_compressed.c lv_binfont_loader.c lv_font_montserrat_10.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_44.c lv_font_montserrat_20.c lv_font_montserrat_38.c lv_font_montserrat_18.c lv_font_montserrat_40.c lv_font_montserrat_28.c lv_font_montserrat_24.c lv_font_montserrat_14.c lv_font_montserrat_36.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font.c lv_font_unscii_16.c lv_font_montserrat_30.c lv_font_montserrat_48.c lv_font_montserrat_42.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_montserrat_16.c lv_font_montserrat_46.c lv_font_montserrat_26.c lv_font_montserrat_8.c
    packages/LVGL-latest/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    packages/LVGL-latest/src/indev/: lv_indev.c lv_indev_scroll.c
    packages/LVGL-latest/src/stdlib/builtin/: lv_sprintf_builtin.c lv_string_builtin.c lv_mem_core_builtin.c lv_tlsf.c
    packages/LVGL-latest/src/stdlib/rtthread/: lv_sprintf_rtthread.c lv_mem_core_rtthread.c lv_string_rtthread.c
    packages/LVGL-latest/src/widgets/win/: lv_win.c
    packages/LVGL-latest/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-latest/src/drivers/display/st7796/: lv_st7796.c
    packages/LVGL-latest/src/stdlib/: lv_mem.c
    packages/LVGL-latest/src/widgets/animimage/: lv_animimage.c
    packages/LVGL-latest/src/others/sysmon/: lv_sysmon.c
    packages/LVGL-latest/src/drivers/nuttx/: lv_nuttx_touchscreen.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_image_cache.c lv_nuttx_fbdev.c lv_nuttx_cache.c lv_nuttx_entry.c
    packages/LVGL-latest/src/drivers/display/ili9341/: lv_ili9341.c
    packages/LVGL-latest/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_vglite_path.c lv_draw_vglite_layer.c lv_draw_vglite.c lv_vglite_buf.c lv_draw_vglite_label.c lv_vglite_utils.c lv_draw_vglite_img.c lv_vglite_matrix.c lv_draw_vglite_arc.c lv_draw_vglite_fill.c lv_draw_vglite_triangle.c lv_draw_vglite_border.c lv_draw_vglite_line.c
    packages/LVGL-latest/src/widgets/tileview/: lv_tileview.c
    packages/LVGL-latest/src/draw/renesas/dave2d/: lv_draw_dave2d_border.c lv_draw_dave2d_line.c lv_draw_dave2d_utils.c lv_draw_dave2d.c lv_draw_dave2d_image.c lv_draw_dave2d_arc.c lv_draw_dave2d_triangle.c lv_draw_dave2d_label.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_fill.c
    packages/LVGL-latest/src/libs/fsdrv/: lv_fs_memfs.c lv_fs_fatfs.c lv_fs_win32.c lv_fs_cbfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_littlefs.c
    packages/LVGL-latest/src/libs/barcode/: lv_barcode.c code128.c
    packages/LVGL-latest/src/widgets/slider/: lv_slider.c
    packages/LVGL-latest/src/drivers/display/st7735/: lv_st7735.c
    packages/LVGL-latest/src/widgets/arc/: lv_arc.c
    packages/LVGL-latest/src/libs/lodepng/: lodepng.c lv_lodepng.c
    packages/LVGL-latest/src/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-latest/src/widgets/spinner/: lv_spinner.c
    packages/LVGL-latest/src/others/imgfont/: lv_imgfont.c
    packages/LVGL-latest/src/osal/: lv_windows.c lv_pthread.c lv_cmsis_rtos2.c lv_freertos.c lv_rtthread.c lv_os_none.c
    packages/LVGL-latest/src/drivers/evdev/: lv_evdev.c
    packages/LVGL-latest/src/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-latest/src/layouts/: lv_layout.c
    packages/LVGL-latest/src/themes/simple/: lv_theme_simple.c
    packages/LVGL-latest/src/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/LVGL-latest/src/misc/cache/: _lv_cache_lru_rb.c lv_image_cache.c lv_cache.c lv_cache_entry.c
    packages/LVGL-latest/src/widgets/table/: lv_table.c
    packages/LVGL-latest/src/drivers/libinput/: lv_xkb.c lv_libinput.c
    packages/LVGL-latest/src/widgets/bar/: lv_bar.c
    packages/LVGL-latest/src/widgets/image/: lv_image.c
    packages/LVGL-latest/src/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-latest/src/others/file_explorer/: lv_file_explorer.c
    packages/LVGL-latest/src/libs/libpng/: lv_libpng.c
    packages/LVGL-latest/src/tick/: lv_tick.c
    packages/LVGL-latest/src/widgets/line/: lv_line.c
    packages/LVGL-latest/src/libs/rle/: lv_rle.c
    packages/LVGL-latest/src/stdlib/clib/: lv_sprintf_clib.c lv_mem_core_clib.c lv_string_clib.c
    packages/LVGL-latest/src/others/observer/: lv_observer.c
    packages/LVGL-latest/src/drivers/x11/: lv_x11_input.c lv_x11_display.c
    packages/LVGL-latest/src/themes/mono/: lv_theme_mono.c
    packages/LVGL-latest/src/widgets/textarea/: lv_textarea.c
    packages/LVGL-latest/src/stdlib/micropython/: lv_mem_core_micropython.c
    packages/LVGL-latest/src/libs/bmp/: lv_bmp.c
    packages/LVGL-latest/src/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-latest/src/widgets/tabview/: lv_tabview.c
    packages/LVGL-latest/src/widgets/label/: lv_label.c
    packages/LVGL-latest/src/drivers/windows/: lv_windows_context.c lv_windows_input.c lv_windows_display.c
    packages/LVGL-latest/src/libs/tjpgd/: tjpgd.c lv_tjpgd.c
    packages/LVGL-latest/src/drivers/display/st7789/: lv_st7789.c
    packages/LVGL-latest/src/libs/rlottie/: lv_rlottie.c
    packages/LVGL-latest/src/widgets/switch/: lv_switch.c
    packages/LVGL-latest/src/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-latest/src/draw/sdl/: lv_draw_sdl.c
    packages/LVGL-latest/src/others/vg_lite_tvg/: vg_lite_matrix.c
    packages/LVGL-latest/src/widgets/checkbox/: lv_checkbox.c
    packages/LVGL-latest/src/libs/bin_decoder/: lv_bin_decoder.c
    packages/LVGL-latest/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    packages/LVGL-latest/src/widgets/imagebutton/: lv_imagebutton.c
    packages/LVGL-latest/src/layouts/flex/: lv_flex.c
    packages/LVGL-latest/src/widgets/menu/: lv_menu.c
    packages/LVGL-latest/src/drivers/display/fb/: lv_linux_fbdev.c
    packages/LVGL-latest/src/widgets/span/: lv_span.c
    packages/LVGL-latest/src/layouts/grid/: lv_grid.c
    packages/LVGL-latest/src/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-latest/src/others/snapshot/: lv_snapshot.c
    packages/LVGL-latest/src/libs/lz4/: lz4.c
    packages/LVGL-latest/src/widgets/list/: lv_list.c
    packages/LVGL-latest/src/widgets/button/: lv_button.c
    packages/LVGL-latest/src/themes/default/: lv_theme_default.c
    packages/LVGL-latest/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-latest/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    packages/LVGL-latest/src/others/gridnav/: lv_gridnav.c
    packages/LVGL-latest/src/widgets/objx_templ/: lv_objx_templ.c
    packages/LVGL-latest/src/others/ime/: lv_ime_pinyin.c
    packages/LVGL-latest/src/widgets/scale/: lv_scale.c
    packages/LVGL-latest/src/widgets/canvas/: lv_canvas.c
    packages/LVGL-latest/src/: lv_init.c
    packages/LVGL-latest/src/widgets/chart/: lv_chart.c
    packages/LVGL-latest/src/others/monkey/: lv_monkey.c
    packages/LVGL-latest/src/widgets/dropdown/: lv_dropdown.c
  group LVGL-demo
    board/lvgl/demo/benchmark/assets/: img_benchmark_cogwheel_alpha256.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_transform_avatar_15.c lv_font_benchmark_montserrat_12_compr_az.c.c lv_font_benchmark_montserrat_16_compr_az.c.c lv_font_benchmark_montserrat_28_compr_az.c.c
    board/lvgl/demo/benchmark/: lv_demo_benchmark.c
    board/lvgl/demo/: lv_demo.c
    board/lvgl/demo/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    board/lvgl/demo/widgets/: lv_demo_widgets.c
  group LVGL-port
    board/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-latest/env_support/rt-thread/: lv_rt_thread_port.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
